# Keil uVision project MK_BOOT.uvproj, settings and files
target MK20D10_Boot (ARM-ADS)
  device: MK20DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: Mk20d10_Boot +hex
  AfterMake: fromelf --bin --output ..\Firmware\Mk20d10_Boot.bin .\obj\Mk20d10_Boot.axf
  c flags: Optim=4
  c include: ..\code\SysApp\inc;..\code\SysBsp\MK20D10;..\code\DevDriver\ymodem
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group SysBsp
    ../code/SysBsp/MK20D10/: mk20d10.c system_MK20D10.c startup_MK20D10.s flash.c
  group DevDriver
    ../code/DevDriver/ymodem/: ymodem.c
  group SysApp
    ../code/SysApp/src/: main.c
target MK22D5_Boot (ARM-ADS)
  device: MK22DX256xxx5 Freescale Semiconductor
  cpu: IROM(0x00000000,0x40000) IROM2(0x10000000,0x10000) IRAM(0x20000000,0x4000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: Mk22d5_Boot +hex
  AfterMake: fromelf --bin --output ..\Firmware\Mk22d5_Boot.bin .\obj\Mk22d5_Boot.axf
  c flags: Optim=4
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
target MK60D10_Boot (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: Mk60d10_Boot +hex
  AfterMake: fromelf --bin --output ..\Firmware\Mk60d10_Boot.bin .\obj\Mk60d10_Boot.axf
  c flags: Optim=4
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
